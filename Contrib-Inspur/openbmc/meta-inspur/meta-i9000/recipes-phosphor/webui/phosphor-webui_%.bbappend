FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI = "git://github.com/inspur-bmc/ocp-i9000-webui;protocol=https"
SRCREV = "87ae9c70f544573f5e7f2f46db3618d3c5c31547"
