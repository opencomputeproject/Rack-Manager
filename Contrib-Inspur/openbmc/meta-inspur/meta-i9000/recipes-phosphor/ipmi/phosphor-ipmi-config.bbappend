FILESEXTRAPATHS_prepend_i9000 := "${THISDIR}/${PN}:"
