FILESEXTRAPATHS_prepend_i9000 := "${THISDIR}/${PN}:"
SRC_URI += "file://i9000.cfg \
            file://0001-Add-i9000-dts-file.patch \
           "
