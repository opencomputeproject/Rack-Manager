FILESEXTRAPATHS_prepend := "${THISDIR}/fstab:"

dirs2775 += "${prefix}/srvroot"

