RDEPENDS_${PN} += "python-pprint"