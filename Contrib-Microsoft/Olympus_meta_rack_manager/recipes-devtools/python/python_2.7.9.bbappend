FILES_${PN}-core += "/usr/lib/python2.7/getpass* "


