FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://shadow.patch"